# Keil uVision project CtrBoard-H7_FDCAN.uvprojx, settings and files
target CtrBoard-H7_FDCAN (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: CtrBoard-H7_FDCAN +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H723xx,AETHOR_DEBUG_UI_ENABLE=0,AETHOR_DEBUG_UI_ALLOW_MOTION=0,AETHOR_DEBUG_UI_ALLOW_MIT=0
  c misc: --no_multibyte_chars
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../User;../App;../App/Config;../App/Protocol;../App/Arm;../App/Motion;../App/Motor;../App/Telemetry;../App/Platform;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../App/DebugUi
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c fdcan.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group App/Protocol
    ../App/Protocol/: ascii_protocol.c text_protocol.c protocol_engine.c
  group App
    ../App/: aethor_app.c
  group App/Config
    ../App/Config/: arm_config.c build_info.c
  group App/Arm
    ../App/Arm/: arm_controller.c joint_reference.c
  group App/Motion
    ../App/Motion/: joint_motion.c joint_motion_can.c
  group App/Motor
    ../App/Motor/: can_frame.c can_tx_scheduler.c motor_bank.c motor_discovery.c motor_runtime.c s3519_codec.c
  group App/Platform
    ../App/Platform/: can_rx_inbox.c usb_cdc_stream.c stm32_platform.c
  group App/Telemetry
    ../App/Telemetry/: diagnostics.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group App/DebugUi
    ../App/DebugUi/: debug_ui_input.c debug_ui_model.c debug_ui_mailbox.c
  group App/Platform/LCD
    ../App/Platform/: lcd_transfer.c lcd_st7789.c lcd_key_adc.c
  group Drivers/LCD HAL
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c
  group Ui
    ../Ui/: debug_ui_graphics_guard.c debug_ui_task.c debug_ui_view.c lv_port_disp.c lv_port_indev.c
    ../Ui/fonts/: ui_font_16.c
  group LVGL 8.3.11
    ../Middlewares/Third_Party/LVGL/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../Middlewares/Third_Party/LVGL/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Middlewares/Third_Party/LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../Middlewares/Third_Party/LVGL/src/extra/: lv_extra.c
    ../Middlewares/Third_Party/LVGL/src/font/: lv_font.c lv_font_fmt_txt.c lv_font_montserrat_16.c lv_font_montserrat_20.c
    ../Middlewares/Third_Party/LVGL/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Middlewares/Third_Party/LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../Middlewares/Third_Party/LVGL/src/widgets/: lv_label.c
target LCD-ReadOnly (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: as above
  output: LCD-ReadOnly +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H723xx,LV_CONF_INCLUDE_SIMPLE=1,AETHOR_DEBUG_UI_ENABLE=1,AETHOR_DEBUG_UI_ALLOW_MOTION=0,AETHOR_DEBUG_UI_ALLOW_MIT=0
  c misc: --no_multibyte_chars
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../User;../App;../App/Config;../App/Protocol;../App/Arm;../App/Motion;../App/Motor;../App/Telemetry;../App/Platform;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../App/DebugUi;../Ui;../Middlewares/Third_Party/LVGL
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  scatter file: .\aethor_memory.sct
target LCD-POS (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: as above
  output: LCD-POS +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H723xx,LV_CONF_INCLUDE_SIMPLE=1,AETHOR_DEBUG_UI_ENABLE=1,AETHOR_DEBUG_UI_ALLOW_MOTION=1,AETHOR_DEBUG_UI_ALLOW_MIT=0,AETHOR_DEBUG_UI_MOTOR7_POS_PROFILE=1
  c misc: --no_multibyte_chars
  c include: as above
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  scatter file: .\aethor_memory.sct
target LCD-MIT (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: as above
  output: LCD-MIT +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H723xx,LV_CONF_INCLUDE_SIMPLE=1,AETHOR_DEBUG_UI_ENABLE=1,AETHOR_DEBUG_UI_ALLOW_MOTION=1,AETHOR_DEBUG_UI_ALLOW_MIT=1,AETHOR_DEBUG_UI_MOTOR7_POS_PROFILE=1,AETHOR_DEBUG_UI_MOTOR7_MIT_PROFILE=1
  c misc: --no_multibyte_chars
  c include: as above
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  scatter file: .\aethor_memory.sct
software components: CMSIS:CORE 4.3.0
